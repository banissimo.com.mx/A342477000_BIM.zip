Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: the_gap_wc_horizontal_outlet.ifc
Time: 2019-03-22T06:15:17
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, THE GAP WC horizontal outlet
ePset_BIMobjectScript - COLOR: WHITE; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): THE GAP WC horizontal outlet; SKU (BO_prodsku): 342477xx0; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): The Gap; ProductGroup (BO_prodgroup): Toilets; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 9/9/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 650; Height (BO_height): 790; Depth (BO_depth): 365; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/342477xx0; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/342477xx0; ProductUrl (BO_producturl): http://www.roca.com/catalogue/products/toilets/close-coupled-toilets/vitreous-china-close-coupled-wc-horizontal-outlet-342477..0; InstallationInstructions (BO_montins): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={E52BC1C1-2175-4B3C-8A3C-1F86BE00FED1}; TechnicalDescription (BO_techcert): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={896DA4F7-5F69-40B5-8AF3-0D6C6B1AC05B}; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Vitreous china; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilets; BimObjectCategoryCode (BO_bocat_code): sanitary-toilets; IfcClassification (BO_ifcclas): Furnishing Element; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7216; Uniclass14Description (BO_uniclass_1_4_desc): Toilets; Uniclass20Code (BO_uniclass_2_0_code): SS-35-65-90; Uniclass20Description (BO_uniclass_2_0_desc): Toilet Systems; NBSReference (BO_nbs_ref): 35-65-90; NBSReferenceDescription (BO_nbs_desc): Toilet Systems; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
